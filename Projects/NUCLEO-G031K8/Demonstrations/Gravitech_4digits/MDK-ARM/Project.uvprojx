# Keil uVision project Project.uvprojx, settings and files
target STM32G031K8_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G031K8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.11
  cpu: IROM(0x08000000-0x800FFFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G031xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G0xx_Nucleo_32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Demo/User
    ../Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0xx_Nucleo_32
    ../../../../../Drivers/BSP/STM32G0xx_Nucleo_32/: stm32g0xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32g031xx.s
software components: CMSIS:CORE 4.3.0
