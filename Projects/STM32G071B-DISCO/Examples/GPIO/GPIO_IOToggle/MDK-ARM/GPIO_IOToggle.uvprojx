# Keil uVision project GPIO_IOToggle.uvprojx, settings and files
target GPIO_IOToggle (ARM-ADS)
  device: STM32G071RBTx STMicroelectronics
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: GPIO_IOToggle +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G071xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/BSP/STM32G071B-Discovery
  library: MicroLIB
  group Example/MDK-ARM
    ./: startup_stm32g071xx.s
  group Example/User
    ../Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G071B-Discovery
    ../../../../../../Drivers/BSP/STM32G071B-Discovery/: stm32g071b_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
