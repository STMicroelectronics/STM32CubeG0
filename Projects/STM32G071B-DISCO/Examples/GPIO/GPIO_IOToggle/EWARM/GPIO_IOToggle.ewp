# IAR project GPIO_IOToggle.ewp, settings and files
configuration GPIO_IOToggle (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G071xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/BSP/STM32G071B-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_IOToggle.hex
  ILINK.IlinkOutputFile: GPIO_IOToggle.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Doc
    ../: readme.txt readme.txt
  group Drivers/BSP/STM32G071B-Discovery
    ../../../../../../Drivers/BSP/STM32G071B-Discovery/: stm32g071b_discovery.c stm32g071b_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c
