# Keil uVision project Templates_LL.uvprojx, settings and files
target Templates_LL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.7
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Templates_LL +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_dac.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32g071xx.s
  group Example/User
    ../Src/: main.c stm32g0xx_it.c
software components: CMSIS:CORE 5.3.0
