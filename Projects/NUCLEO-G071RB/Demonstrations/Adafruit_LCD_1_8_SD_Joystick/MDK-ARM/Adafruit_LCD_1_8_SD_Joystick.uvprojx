# Keil uVision project Adafruit_LCD_1_8_SD_Joystick.uvprojx, settings and files
target Adafruit_LCD_1_8_SD_Joystick (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.5
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Adafruit_LCD_1_8_SD_Joystick +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G071xx,
  c include: ../FATFS/Target;../FATFS/App;../Core/Inc;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/STM32G0xx_Nucleo;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Application/User/FatFs/Target
    ../FATFS/Target/: sd_diskio.c
  group Application/User/FatFs/App
    ../FATFS/App/: app_fatfs.c
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0xx_Nucleo
    ../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_gpio.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
software components: CMSIS:CORE 4.3.0
