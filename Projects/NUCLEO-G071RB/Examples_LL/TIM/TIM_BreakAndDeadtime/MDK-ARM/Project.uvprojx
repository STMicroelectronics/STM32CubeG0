# Keil uVision project Project.uvprojx, settings and files
target STM32G071RB-Nucleo_TIM_BreakAndDeadtime (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.4
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G071xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_LL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_tim.c stm32g0xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32g071xx.s
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32g0xx_it.c
software components: CMSIS:CORE 4.3.0
