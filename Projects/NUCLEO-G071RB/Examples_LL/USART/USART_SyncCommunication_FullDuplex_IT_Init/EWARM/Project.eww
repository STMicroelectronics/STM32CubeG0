<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USART_SyncCommunication_FullDuplex_IT_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>
