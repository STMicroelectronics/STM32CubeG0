<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DAC_GenerateWaveform_TriggerHW.ewp</path>
  </project>
  <batchBuild/>
</workspace>


