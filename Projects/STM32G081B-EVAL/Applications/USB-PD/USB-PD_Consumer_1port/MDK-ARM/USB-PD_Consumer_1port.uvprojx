# Keil uVision project USB-PD_Consumer_1port.uvprojx, settings and files
target USB-PD_Consumer_1port (5060020::V5.06 (build 20)::ARMCC)
  device: STM32G081RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.5
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: USB-PD_Consumer_1port +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USBPD_PORT_COUNT=1,USBPDCORE_LIB_PD3_FULL,_RTOS,_SNK,USE_HAL_DRIVER,STM32G081xx,_TRACE,_GUI_INTERFACE,__DEBUG_CAD
  c include: ../Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Utilities/GUI_INTERFACE; ../../../../../../Utilities/TRACER_EMB; ../../../../../../Drivers/CMSIS/Include
  asm include: ..//Inc;..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g081xx.s
  group Application/User
    ../Src/: main.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_pwr_user.c stm32g0xx_it.c app_freertos.c usbpd.c usbpd_vdm_user.c usbpd_dpm_core.c stm32g0xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_lptim.c stm32g0xx_ll_adc.c stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_hal_gpio.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_dma.c stm32g0xx_ll_usart.c stm32g0xx_ll_rcc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_ll_utils.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_tim.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Middlewares/GUI_INTERFACE_Utility
    ../../../../../../Utilities/GUI_INTERFACE/: data_struct_tlv.c bsp_gui.c gui_api.c
  group Middlewares/Tracer_Emb_Utility
    ../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
  group Middlewares/USBPD
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_Keil.lib
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
