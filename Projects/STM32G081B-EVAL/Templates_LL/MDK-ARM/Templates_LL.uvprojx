# Keil uVision project Templates_LL.uvprojx, settings and files
target Templates_LL (6130001::V6.13.1::.\ARMCLANG)
  device: STM32G081RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.7
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Templates_LL +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G081xx,
  c include: ../Inc;../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g081xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
software components: CMSIS:CORE 5.3.0
