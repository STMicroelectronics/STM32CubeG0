# Keil uVision project Project.uvprojx, settings and files
target STM32G081B_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G081RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.4
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32G081B-EVAL_DEMO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G081xx,USE_HAL_DRIVER,USE_STM32G081B_EVAL, LCD_DEFAULT_FONT=Font20
  c misc: --C99
  c include: ../Inc;../../Config;../../Common/Inc;../../Core/Inc;../../DemoLegacy/Modules/lowpower;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G081B_EVAL;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\STM32G081B-EVAL_DEMO.sct
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/Core
    ../../Core/Src/: k_storage.c k_widgets.c k_window.c
  group Application/User
    ../Src/: stm32g0xx_hal_msp.c main.c stm32g0xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32g081xx.s
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Drivers/STM32G0xx_HAL_Drivers
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_adc.c stm32g0xx_hal_uart.c stm32g0xx_hal_rtc.c stm32g0xx_hal.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_i2c.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_gpio.c stm32g0xx_hal_cortex.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Drivers/BSP/STM32G081B_EVAL
    ../../../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval.c stm32g081b_eval_lcd.c stm32g081b_eval_sd.c
  group Application/Common
    ../../Common/Src/: sd_diskio.c utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
