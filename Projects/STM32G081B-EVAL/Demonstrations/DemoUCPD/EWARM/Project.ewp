# IAR project Project.ewp, settings and files
configuration STM32G081B-EVAL_Demo-UCPD-Relocate (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081RB ST STM32G081RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G081xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; USBPDCORE_LIB_PD3_FULL; _DRP; _VDM; _TRACE_NA; _RTOS; USBPD_PORT_COUNT=2; _PPS; RELOCATE; LCD_DEFAULT_FONT=Font16; _VCONN_SUPPORT
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32G0XX\inc; ..\..\..\..\..\Drivers\BSP\STM32G081B_EVAL; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\TRACER_EMB; ..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: ..\..\..\..\Binary\SD_card\BIN\Ucpd.bin
  ILINK.IlinkOutputFile: Ucpd.out
  ILINK.IlinkConfigDefines: __ICFEDIT_size_cstack__=0x300; __ICFEDIT_size_heap__=0x840
  ILINK.IlinkIcfFile: stm32g081xx_flash_relocate.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32G081B-EVAL_Demo-UCPD-Standalone (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32G081xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; _DRP; _VDM; _TRACE; _RTOS; USBPD_PORT_COUNT=2; USBPDCORE_LIB_PD3_FULL; _VCONN_SUPPORT; _PPS; _GUI_INTERFACE; LCD_DEFAULT_FONT=Font16; _VCONN_SUPPORT; _MANU_INFO; _SRC_CAPA_EXT
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32G0XX\inc; ..\..\..\..\..\Drivers\BSP\STM32G081B_EVAL; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\GUI_INTERFACE; ..\..\..\..\..\Utilities\TRACER_EMB
  OBJCOPY.OOCOutputFile: EVAL.bin
  ILINK.IlinkOutputFile: EVAL.out
  ILINK.IlinkIcfFile: stm32g081xx_flash_GUI.icf
  group Application/EWARM
    ../Src/: system_stm32g0xx.c
  group Application/User
    ../Src/: demo_application.c main.c stm32g0xx_it.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_vdm_user.c
  group Application/Utilities/Fonts
    ../../../../../Utilities/Fonts/: fonts.h
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/cbtl08gp053/: cbtl08gp053.c
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/sn65dp141/: sn65dp141.c
    ../../../../../Drivers/BSP/Components/tusb546/: tusb546.c
  group Drivers/BSP/STM32G081B_EVAL
    ../../../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval.c stm32g081b_eval_lcd.c stm32g081b_eval_mux.c stm32g081b_eval_pwr.c
  group Drivers/CMSIS
    ./: startup_stm32g081xx.s
  group Drivers/HAL
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c usbpd_trace.c
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_wc32.a
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0xx
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Utilities/GUI_INTERFACE
    ../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
  group Utilities/TRACER_EMB
    ../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
