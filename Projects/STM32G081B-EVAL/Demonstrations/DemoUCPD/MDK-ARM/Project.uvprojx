# Keil uVision project Project.uvprojx, settings and files
target STM32G081B-EVAL_Demo-UCPD-Standalone (5060020::V5.06 (build 20)::ARMCC)
  device: STM32G081RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.5
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G081xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,_DRP,_VDM,_TRACE,_RTOS,USBPD_PORT_COUNT=2,USBPDCORE_LIB_PD3_FULL,_PPS,_VCONN_SUPPORT,_GUI_INTERFACE,LCD_DEFAULT_FONT=Font16,_MANU_INFO,_SRC_CAPA_EXT
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/inc;../../../../../Drivers/BSP/STM32G081B_EVAL;../../../../../Utilities/Log;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/GUI_INTERFACE;../../../../../Utilities/TRACER_EMB
  asm define: STM32G081xx USE_HAL_DRIVER
  asm include: ../Inc;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f800
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Drivers/HAL
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_dma.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal.c stm32g0xx_ll_rcc.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c stm32g0xx_hal_spi.c stm32g0xx_hal_cortex.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_lptim.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c usbpd_dpm_core.c
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_Keil.lib
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0xx
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_pwr_hw_if.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_cad_hw_if.c usbpd_hw_if_it.c usbpd_timersserver.c usbpd_hw.c
  group Drivers/CMSIS
    ./: startup_stm32g081xx.s
  group Drivers/BSP/STM32G081B_EVAL
    ../../../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval_lcd.c stm32g081b_eval.c stm32g081b_eval_pwr.c stm32g081b_eval_mux.c
  group Application/MDK-ARM
    ../Src/: system_stm32g0xx.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c queue.c
  group Application/User
    ../Src/: main.c usbpd_dpm_user.c usbpd_pwr_if.c stm32g0xx_it.c demo_application.c usbpd_vdm_user.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/cbtl08gp053/: cbtl08gp053.c
    ../../../../../Drivers/BSP/Components/sn65dp141/: sn65dp141.c
    ../../../../../Drivers/BSP/Components/tusb546/: tusb546.c
  group Utilities/TRACER_EMB
    ../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
  group Utilities/GUI_INTERFACE
    ../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
software components: CMSIS:CORE 5.0.1
