# Keil uVision project Project.uvprojx, settings and files
target STM32G081B-EVAL_Demo-Legacy-Standalone (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G081RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.4
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32G081B-EVAL_DEMO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G081xx,USE_STM32G081B_EVAL,STANDALONE
  c misc: --C99
  c include: ../Demo/Inc;../../Config;../../Core/Inc;../../Common/Inc;../Modules/main_app;../Modules/thermometer_ldr;../Modules/imagebrowser;../Modules/filebrowser;../Modules/lowpower;../Modules/audio;../Modules/calendar;../Modules/help;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32G081B_EVAL;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Application/Common
    ../../Common/Src/: utils.c sd_diskio.c
  group Application/Core
    ../../Core/Src/: k_widgets.c k_module.c k_demo.c k_tools.c k_storage.c k_window.c k_menu.c
  group Application/MDK-ARM
    ./: startup_stm32g081xx.s
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Application/Modules/Audio
    ../Modules/audio/: wave_player.c wave_recorder.c app_audio.c
  group Drivers/BSP/STM32G081B_EVAL
    ../../../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval.c stm32g081b_eval_lcd.c stm32g081b_eval_tsensor.c stm32g081b_eval_sd.c
  group Application/Demo
    ../Demo/Src/: stm32g0xx_it.c main.c stm32g0xx_hal_msp.c
  group Application/Modules/LowPower
    ../Modules/lowpower/: app_lowpower.c
  group Drivers/STM32G0xx_HAL_Drivers
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_cortex.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_dac.c stm32g0xx_hal.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_tim.c stm32g0xx_hal_adc.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_rcc.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_rtc.c
  group Middlewares/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/Modules/ImageViewer
    ../Modules/imagebrowser/: app_imagesbrowser.c
  group Drivers/CMSIS
    ../Demo/Src/: system_stm32g0xx.c
  group Application/Modules/MainApp
    ../Modules/main_app/: app_main.c
  group Application/Modules/Help
    ../Modules/help/: app_help.c
  group Application/Modules/Calendar
    ../Modules/calendar/: app_calendar.c
  group Application/Modules/Thermometer_LDR
    ../Modules/thermometer_LDR/: app_thermometer_LDR.c
  group Application/Modules/FileBrowser
    ../Modules/filebrowser/: app_filesbrowser.c
target STM32G081B-EVAL_Demo-Legacy-Relocate (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G081RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.0.0.4
  cpu: as above
  output: STM32G081B-EVAL_DEMO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G081xx,USE_STM32G081B_EVAL,RELOCATE,LCD_DEFAULT_FONT=Font20
  c misc: --C99
  c include: as above
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0
