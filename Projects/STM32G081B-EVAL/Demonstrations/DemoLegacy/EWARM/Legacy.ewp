# IAR project Legacy.ewp, settings and files
configuration STM32G081B-EVAL_Demo-Legacy-Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081RB ST STM32G081RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G081xx; USE_STM32G081B_EVAL; STANDALONE; LCD_DEFAULT_FONT=Font20
  ICCARM.CCIncludePath2: ..\Demo\Inc; ..\..\Config; ..\..\Core\Inc; ..\..\Common\Inc; ..\Modules\main_app; ..\Modules\thermometer_LDR; ..\Modules\imagebrowser; ..\Modules\filebrowser; ..\Modules\lowpower; ..\Modules\audio; ..\Modules\calendar; ..\Modules\help; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32G081B_EVAL; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32CubeG0_Demo_STM32G081B_EVAL.hex
  ILINK.IlinkOutputFile: STM32G081B-EVAL_DEMO.out
  ILINK.IlinkIcfFile: stm32g081xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32G081B-EVAL_Demo-Legacy-Relocate (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G081xx; USE_STM32G081B_EVAL; RELOCATE; LCD_DEFAULT_FONT=Font20
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Legacy.bin
  ILINK.IlinkIcfFile: stm32g081xx_flash_relocate.icf
  group Application/Common
    ../../Common/Src/: sd_diskio.c utils.c
  group Application/Core
    ../../Core/Src/: k_demo.c k_menu.c k_module.c k_storage.c k_tools.c k_widgets.c k_window.c
  group Application/Demo
    ../Demo/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/EWARM
    ./: startup_stm32g081xx.s
  group Application/Modules/Audio
    ../Modules/audio/: app_audio.c wave_player.c wave_recorder.c
  group Application/Modules/Calendar
    ../Modules/calendar/: app_calendar.c
  group Application/Modules/FileBrowser
    ../Modules/filebrowser/: app_filesbrowser.c
  group Application/Modules/Help
    ../Modules/help/: app_help.c
  group Application/Modules/ImageViewer
    ../Modules/imagebrowser/: app_imagesbrowser.c
  group Application/Modules/LowPower
    ../Modules/lowpower/: app_lowpower.c
  group Application/Modules/MainApp
    ../Modules/main_app/: app_main.c
  group Application/Modules/Thermometer_LDR
    ../Modules/thermometer_LDR/: app_thermometer_ldr.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
  group Drivers/BSP/STM32G081B_EVAL
    ../../../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval.c stm32g081b_eval_lcd.c stm32g081b_eval_sd.c stm32g081b_eval_tsensor.c
  group Drivers/CMSIS
    ../Demo/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Drivers
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
