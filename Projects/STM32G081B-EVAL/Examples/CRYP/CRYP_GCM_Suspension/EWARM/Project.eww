<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CRYP_GCM_Suspension.ewp</path>
  </project>
  <batchBuild />
</workspace>
