<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CRYP_GCM_GMAC_CCM_Modes.ewp</path>
  </project>
  <batchBuild />
</workspace>
