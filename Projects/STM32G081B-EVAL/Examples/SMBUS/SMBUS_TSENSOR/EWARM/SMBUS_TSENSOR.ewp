# IAR project SMBUS_TSENSOR.ewp, settings and files
configuration SMBUS_TSENSOR (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081RB ST STM32G081RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G081xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/BSP/STM32G081B_EVAL; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SMBUS_TSENSOR.hex
  ILINK.IlinkOutputFile: SMBUS_TSENSOR.out
  ILINK.IlinkIcfFile: stm32g081xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g081xx.s
  group Application/User
    ../Src/: stm32g0xx_tsensor.c main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Drivers/BSP/STM32G081B_EVAL
    ../../../../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval_lcd.c stm32g081b_eval.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_smbus.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Doc
    ../: readme.txt
