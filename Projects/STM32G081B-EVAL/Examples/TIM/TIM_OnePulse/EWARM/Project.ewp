# IAR project Project.ewp, settings and files
configuration STM32G081B_EVAL_TIM_OnePulse (ARM, debug)
  General.OGChipSelectEditMenu: STM32G081RB ST STM32G081RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G081xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32G081B_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g081xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Example/EWARM
    ./: startup_stm32g081xx.s
  group Drivers/BSP/STM32G081B_EVAL
    ../../../../../../Drivers/BSP/STM32G081B_EVAL/: stm32g081b_eval.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc.c stm32g0xx_hal_tim.c stm32g0xx_hal_dma.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
