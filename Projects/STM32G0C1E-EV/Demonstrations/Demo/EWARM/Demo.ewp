# IAR project Demo.ewp, settings and files
configuration STM32G0C1E-EV (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0C1CE ST STM32G0C1CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G0C1xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; USBPDCORE_LIB_PD3_FULL; _DRP; _SNK; _VDM; _TRACE; _GUI_INTERFACE; _RTOS; USBPD_PORT_COUNT=2; _PPS; RELOCATE; LCD_DEFAULT_FONT=Font16; _VCONN_SUPPORT; _SRC_CAPA_EXT=USBPD_TRUE; _MANU_INFO=USBPD_TRUE
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Config; ..\..\Common\Inc; ..\..\Core\Inc; ..\..\Modules\audio; ..\..\Modules\calendar; ..\..\Modules\filebrowser; ..\..\Modules\help; ..\..\Modules\imagebrowser; ..\..\Modules\lowpower; ..\..\Modules\main_app; ..\..\Modules\thermometer_LDR; ..\..\Modules\ucpd; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32G0C1E-EV; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32G0XX\inc; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\TRACER_EMB; ..\..\..\..\..\Utilities\GUI_INTERFACE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Modules\ucpd; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: STM32CubeG0_Demo_STM32G0C1E-EV.hex
  ILINK.IlinkOutputFile: STM32G0C1E-EV_DEMO.out
  ILINK.IlinkIcfFile: stm32g0c1xx_flash_GUI.icf
  ILINK.IlinkExtraOptions: --basic_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Common
    ../../Common/Src/: sd_diskio.c utils.c
  group Application/Core
    ../../Core/Src/: k_demo.c k_menu.c k_module.c k_storage.c k_tools.c k_widgets.c k_window.c
  group Application/EWARM
    ./: startup_stm32g0c1xx.s
  group Application/Modules/Audio
    ../../Modules/audio/: app_audio.c wave_player.c wave_recorder.c
  group Application/Modules/Calendar
    ../../Modules/calendar/: app_calendar.c
  group Application/Modules/FileBrowser
    ../../Modules/filebrowser/: app_filesbrowser.c
  group Application/Modules/Help
    ../../Modules/help/: app_help.c
  group Application/Modules/ImageBrowser
    ../../Modules/imagebrowser/: app_imagesbrowser.c
  group Application/Modules/Lowpower
    ../../Modules/lowpower/: app_lowpower.c
  group Application/Modules/MainApp
    ../../Modules/main_app/: app_main.c
  group Application/Modules/Thermometer_LDR
    ../../Modules/thermometer_LDR/: app_thermometer_ldr.c
  group Application/Modules/Ucpd
    ../../Modules/ucpd/: demo_application.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_vdm_user.c
  group Application/User
    ../Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c SubDemoLegacy.c SubDemoUcpd.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/cbtl08gp053/: cbtl08gp053.c
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/sn65dp141/: sn65dp141.c
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../../../Drivers/BSP/Components/tusb546/: tusb546.c
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval.c stm32g0c1e_eval_lcd.c stm32g0c1e_eval_mux.c stm32g0c1e_eval_pwr.c stm32g0c1e_eval_sd.c stm32g0c1e_eval_tsensor.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Drivers
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group Middlewares/ST/STM32_USBPD_Library/Core
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_dpm_core.c usbpd_trace.c
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_wc32.a
  group Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0xx
    ../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Middlewares/Third_Party/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/Third_Party/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Utilities/GUI_INTERFACE
    ../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
  group Utilities/Tracer_Emb
    ../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
