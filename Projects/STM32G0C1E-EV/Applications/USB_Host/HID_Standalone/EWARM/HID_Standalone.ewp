# IAR project HID_Standalone.ewp, settings and files
configuration HID_HOST_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0C1CE ST STM32G0C1CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32G0C1xx; USBPD_PORT_COUNT=1; USBPDCORE_LIB_NO_PD; USBPD_TYPE_STATE_MACHINE; _SRC
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\USB_Host\App; ..\USB_Host\Target; ..\USB-PD; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32G0XX\inc; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Drivers\BSP\STM32G0C1E-EV
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_Standalone.hex
  ILINK.IlinkOutputFile: HID_Standalone.out
  ILINK.IlinkIcfFile: stm32g0c1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0c1xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/USB-PD
    ../USB-PD/: usbpd.c usbpd_dpm_core.c usbpd_dpm_user.c usbpd_pwr_if.c
  group Application/User/USB_Host/App
    ../USB_Host/App/: keyboard.c mouse.c usb_host.c
  group Application/User/USB_Host/Target
    ../USB_Host/Target/: usbh_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval.c stm32g0c1e_eval_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_hcd.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_pwr.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usb.c
  group Middlewares/STM32_USBPD_Library
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM0PLUS_wc32.a
  group Middlewares/USB_HOST/Class
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Middlewares/USB_HOST/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
