# Keil uVision project OpenBootloader.uvprojx, settings and files
target STM32G0C1E-EV (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G0C1VETx STMicroelectronics
  pack: Keil.STM32G0Bx_DFP.0.0.1
  cpu: IROM(0x08000000-0x80097FF) IRAM(0x20000000-0x20002BFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: OpenBootloader - STM32G0C1E-EV +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0C1xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../Middlewares/ST/OpenBootloader/Modules/USART;../OpenBootloader/Target;../../../../../Middlewares/ST/OpenBootloader/Core;../../../../../Middlewares/ST/OpenBootloader/Modules/Mem;../OpenBootloader/App;../../../../../Middlewares/ST/OpenBootloader/Modules/I2C;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/ST/OpenBootloader/Modules/USB;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../USB_Device/App;../USB_Device/Target;../../../../../Middlewares/ST/OpenBootloader/Modules/FDCAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x9800
  memory RVCT9: RAM 0x20000000 size 0x2c00
  group Application/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32g0c1xx.s
  group Application/Openbootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/Openbootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c fdcan_interface.c flash_interface.c i2c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c systemmemory_interface.c usart_interface.c usb_interface.c
  group Application/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_dfu_if.c
  group Application/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_hcd.c stm32g0xx_hal_i2c.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_crs.c stm32g0xx_ll_dma.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_rcc.c stm32g0xx_ll_usart.c stm32g0xx_ll_usb.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/FDCAN
    ../../../../../Middlewares/ST/OpenBootloader/Modules/FDCAN/: openbl_fdcan_cmd.c
  group Middlewares/OpenBootloader/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
  group Middlewares/OpenBootloader/Modules/USB
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USB/: openbl_usb_cmd.c
  group Middlewares/USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
software components: CMSIS:CORE 4.3.0
