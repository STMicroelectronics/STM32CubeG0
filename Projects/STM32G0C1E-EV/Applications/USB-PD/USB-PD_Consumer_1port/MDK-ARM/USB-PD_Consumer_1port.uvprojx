# Keil uVision project USB-PD_Consumer_1port.uvprojx, settings and files
target USB-PD_Consumer_1port (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G0C1VETx STMicroelectronics
  pack: Keil.STM32G0Bx_DFP.0.0.1
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: USB-PD_Consumer_1port +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USBPD_PORT_COUNT=1,_RTOS,_SNK,_TRACE,_GUI_INTERFACE,USBPDCORE_LIB_PD3_FULL,USE_HAL_DRIVER,STM32G0C1xx
  c include: ../Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/GUI_INTERFACE; ../../../../../../Utilities/TRACER_EMB; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32G0C1E-EV
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0c1xx.s
  group Application/User
    ../Src/: main.c app_freertos.c usbpd.c usbpd_dpm_user.c usbpd_pwr_user.c usbpd_pwr_if.c usbpd_vdm_user.c usbpd_dpm_core.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval_pwr.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c stm32g0xx_ll_crs.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_lptim.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_usart.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Middlewares/USBPD
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_Keil.lib
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Utilities
    ../../../../../../Utilities/GUI_INTERFACE/: data_struct_tlv.c bsp_gui.c gui_api.c
    ../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
software components: CMSIS:CORE 4.3.0
