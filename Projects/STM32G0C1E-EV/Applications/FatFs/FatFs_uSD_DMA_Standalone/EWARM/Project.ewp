# IAR project Project.ewp, settings and files
configuration Templates_FatFs_uSD_DMA_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0C1VE ST STM32G0C1VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G0C1xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../FatFs/App; ../FatFs/Target; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/CMSIS/Include; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\..\Drivers\BSP\STM32G0C1E-EV
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32g0c1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0c1xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/FatFs/App
    ../FatFs/App/: app_fatfs.c
  group Application/User/FatFs/Target
    ../FatFs/Target/: sd_diskio.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval.c stm32g0c1e_eval_sd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
