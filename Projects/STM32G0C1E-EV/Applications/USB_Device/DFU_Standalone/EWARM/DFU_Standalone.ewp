# IAR project DFU_Standalone.ewp, settings and files
configuration DFU_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0C1CE ST STM32G0C1CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G0C1xx; USE_FULL_LL_DRIVER; USBPDCORE_LIB_NO_PD; USBPD_PORT_COUNT=1; _SNK; USBPD_TYPE_STATE_MACHINE
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\STM32G0C1E-EV; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc; ..\USB_Device\App; ..\USB_Device\Target; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Core\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USBPD_Library\Devices\STM32G0XX\inc; ..\USB-PD\Target; ..\USB-PD
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DFU_Standalone.hex
  ILINK.IlinkOutputFile: DFU_Standalone.out
  ILINK.IlinkIcfFile: stm32g0c1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0c1xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/USB-PD
    ../USB-PD/: usbpd.c usbpd_dpm_core.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_usb_if.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_dfu_flash.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval.c stm32g0c1e_eval_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usb.c
  group Middlewares/STM32_USBPD_Library
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM0PLUS_wc32.a
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
