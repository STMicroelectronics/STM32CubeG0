# Keil uVision project MSC_Standalone.uvprojx, settings and files
target MSC_Standalone (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G0C1CETx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IROM(0x08000000-0x807FFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: MSC_Standalone +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0C1xx,USE_FULL_LL_DRIVER,USBPDCORE_LIB_NO_PD,_SNK,USBPD_PORT_COUNT=1,_SNK
  c include: ../../../../../../Drivers/BSP/STM32G0C1E-EV;../../../../../../Drivers/CMSIS;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/CMSIS/Core/Include;../Core/Inc;../Core/Src;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../USB_Device/App;../USB_Device/Target;../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/inc;../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../USB-PD/Target;../USB-PD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: 0xf4ffffff size 0x3100ef06
  group Application/MDK-ARM
    ./: startup_stm32g0c1xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/User/USB-PD
    ../USB-PD/: usbpd.c usbpd_dpm_core.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_usb_if.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval.c stm32g0c1e_eval_sd.c stm32g0c1e_eval_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usb.c
  group Middlewares/STM32_USBPD_Library
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM0PLUS_Keil.lib
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
software components: CMSIS:CORE 4.3.0
