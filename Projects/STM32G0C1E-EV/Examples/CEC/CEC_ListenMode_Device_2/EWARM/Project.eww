<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CEC_ListenMode_Device_2.ewp</path>
  </project>
  <batchBuild />
</workspace>
