<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CEC_DataExchange_Device_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
