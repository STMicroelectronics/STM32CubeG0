<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CEC_MultiAddress_Device_2.ewp</path>
  </project>
  <batchBuild />
</workspace>
