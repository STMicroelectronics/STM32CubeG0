# IAR project ADC_AnalogWatchdog.ewp, settings and files
configuration ADC_AnalogWatchdog (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0C1VE ST STM32G0C1VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G0C1xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32G0C1E-EV
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_AnalogWatchdog.hex
  ILINK.IlinkOutputFile: ADC_AnalogWatchdog.out
  ILINK.IlinkIcfFile: stm32g0c1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g0c1xx.s
  group Application/User
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G0C1E-EV
    ../../../../../../Drivers/BSP/STM32G0C1E-EV/: stm32g0c1e_eval.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_exti.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
