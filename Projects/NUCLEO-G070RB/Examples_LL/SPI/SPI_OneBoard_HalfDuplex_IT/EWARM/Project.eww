<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\SPI_OneBoard_HalfDuplex_IT.ewp</path>
  </project>
  <batchBuild/>
</workspace>
