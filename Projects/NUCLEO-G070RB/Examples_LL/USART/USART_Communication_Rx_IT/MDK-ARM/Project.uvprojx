# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-G070RB_USART_Communication_Rx_IT (ARM-ADS)
  device: STM32G070RBTx STMicroelectronics
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20008FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32G070xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32g0xx_it.c
  group Drivers/STM32G0xx_LL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
