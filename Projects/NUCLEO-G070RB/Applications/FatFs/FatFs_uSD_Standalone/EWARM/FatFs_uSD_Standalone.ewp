# IAR project FatFs_uSD_Standalone.ewp, settings and files
configuration FatFs_uSD_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070RB ST STM32G070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G070xx
  ICCARM.CCIncludePath2: ../FATFS/Target; ../FATFS/App; ../Core/Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/Third_Party/FatFs/src; ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32G0xx_Nucleo; ../../../../../../Drivers/BSP/Adafruit_Shield; ../../../../../../Drivers/BSP/Components; ../../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FatFs_uSD_Standalone.hex
  ILINK.IlinkOutputFile: FatFs_uSD_Standalone.out
  ILINK.IlinkIcfFile: stm32g070xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/STM32G0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G0xx_Nucleo/: stm32g0xx_nucleo.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
